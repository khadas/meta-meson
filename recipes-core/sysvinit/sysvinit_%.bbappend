FILESEXTRAPATHS:prepend := "${THISDIR}/files/:"
SRC_URI:append = " file://reboot_with_parameter.patch"
