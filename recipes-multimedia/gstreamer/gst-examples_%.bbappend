RRECOMMENDS_${PN}:remove = "gstreamer1.0-plugins-ugly-meta"
