EXTRA_OECONF_append = " \
                --disable-decoder=ac3 \
                --disable-decoder=eac3 \
                --disable-decoder=ac3_fixed \
                --disable-decoder=dca \
                --disable-encoder=dca \
                --disable-decoder=h264 \
                --disable-decoder=hevc \
                --disable-decoder=vp9 \
                --disable-decoder=mpeg2video \
                "

