CFLAGS_append = " -fPIC "