
unset DEFAULT_PREFERENCE
