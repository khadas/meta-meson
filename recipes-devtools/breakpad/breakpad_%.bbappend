FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += " \
    file://0001-fix-netflix-plugins-compille-depends-error.patch \
    "
