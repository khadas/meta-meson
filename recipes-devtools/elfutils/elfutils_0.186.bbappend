RDEPENDS:${PN}-ptest:remove += " gcc-symlinks binutils-symlinks"
