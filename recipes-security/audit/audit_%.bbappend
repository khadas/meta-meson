FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-Make-IPX-packet-interpretation-dependent-on-the-ipx-header.patch"
#SRC_URI += "file://0002-Fixed-swig-host-contamination-issue.patch"

