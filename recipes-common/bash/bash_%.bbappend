INSANE_SKIP_${PN}-ptest += "build-deps"

