SUMMARY = "Example DirectFB applications"

FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "\
            file://0012-Input-Text-Test.patch \
            "
