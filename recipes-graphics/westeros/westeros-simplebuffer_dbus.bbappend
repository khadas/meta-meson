LIC_FILES_CHKSUM = "file://${LICENSE_LOCATION};md5=8fb65319802b0c15fc9e0835350ffa02"

#EXTERNALSRC_pn-westeros-simplebuffer=""
include westeros_rev.inc
